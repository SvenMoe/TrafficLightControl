# IAR project TrafficLightControl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: active.cpp active.h Amber.cpp Amber.h flashing.cpp flashing.h GPIO.cpp GPIO.h Green.cpp Green.h HardwareOutput.cpp HardwareOutput.h LightControl.cpp LightControl.h main.cpp Off.cpp Off.h OutputFormat.cpp OutputFormat.h Red.cpp Red.h RedAmber.cpp RedAmber.h regtypes.h SoftwareOutput.cpp SoftwareOutput.h state.cpp state.h TrafficLight.cpp UserButtons.cpp UserButtons.h UserLEDs.cpp UserLEDs.h
