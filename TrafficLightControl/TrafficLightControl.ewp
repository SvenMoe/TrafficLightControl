# IAR project TrafficLightControl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: active.cpp active.h Aus.cpp Aus.h flashing.cpp flashing.h GPIO.cpp GPIO.h Green.cpp Green.h LightControl.cpp LightControl.h main.cpp Red.cpp Red.h RedYellow.cpp RedYellow.h regtypes.h state.cpp state.h TrafficLight.cpp UserButtons.cpp UserButtons.h UserLEDs.cpp UserLEDs.h Yellow.cpp Yellow.h
